# Keil uVision project Damo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: Damo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP\WDT;.\APP\Task;.\APP\TimeBase
  group Source Group 1
    ./: STARTUP.A51
  group main
    ./: main.c
  group WDT
    ./APP/WDT/: WDT.c
  group TimeBase
    ./APP/TimeBase/: TimeBase.c
  group Task
    ./APP/Task/: Task.c
